# Keil uVision project Serial_Communication_Basis.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC11F02E STC
  cpu: IRAM(0-0xFF) IROM(0-0x7FF) CLOCK(45000000)
  output: Serial_Communication_Basis +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: main.c
